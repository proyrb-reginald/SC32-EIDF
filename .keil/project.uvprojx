# Keil uVision project project.uvprojx, settings and files
target Main (6230000::V6.23::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: project +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 v6Lto=1 wLevel=4
  c define: SC32R803, PrintfEnable, LV_CONF_INCLUDE_SIMPLE, LV_LVGL_H_INCLUDE_SIMPLE
  c include: ..\.cmsis\inc;..\dev\st7789v;..\dev\w25q64;..\hal\inc;..\mid\freertos\inc;..\mid\freertos\port\gcc\arm\cm0;..\mid\littlefs;..\mid\lvgl;..\mid\lvgl\port;..\user;..\user\fs;..\user\gui;..\user\gui\design;..\user\log;..\user\os
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group .cmsis/dev/arm/cm0p/
    ../.cmsis/dev/arm/cm0p/: startup_sc32r803.s
  group dev/st7789v/
    ../dev/st7789v/: st7789v.c
  group dev/w25q64/
    ../dev/w25q64/: w25q64.c
  group hal/src/
    ../hal/src/: sc32f1xxx_adc.c sc32f1xxx_btm.c sc32f1xxx_can.c sc32f1xxx_cmp.c sc32f1xxx_crc.c sc32f1xxx_dac.c sc32f1xxx_dma.c sc32f1xxx_gpio.c sc32f1xxx_iap.c sc32f1xxx_int.c sc32f1xxx_lcd.c sc32f1xxx_led.c sc32f1xxx_ledpwm.c sc32f1xxx_op.c sc32f1xxx_option.c sc32f1xxx_pga.c sc32f1xxx_pwm.c sc32f1xxx_pwr.c sc32f1xxx_qep.c sc32f1xxx_qspi.c sc32f1xxx_rcc.c sc32f1xxx_spi.c sc32f1xxx_spi1_twi1.c sc32f1xxx_temper.c sc32f1xxx_tim.c sc32f1xxx_twi.c sc32f1xxx_uart.c sc32f1xxx_vref.c sc32f1xxx_wdt.c system_sc32f1xxx.c
  group mid/freertos/
    ../mid/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group mid/freertos/port/gcc/arm/cm0/
    ../mid/freertos/port/gcc/arm/cm0/: port.c portasm.c
  group mid/freertos/port/mem/
    ../mid/freertos/port/mem/: heap_4.c
  group mid/littlefs/
    ../mid/littlefs/: lfs.c lfs_util.c
  group mid/lvgl/port/
    ../mid/lvgl/port/: lv_port_disp.c lv_port_indev.c
  group mid/lvgl/src/
    ../mid/lvgl/src/: lv_init.c
  group mid/lvgl/src/core/
    ../mid/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group mid/lvgl/src/display/
    ../mid/lvgl/src/display/: lv_display.c
  group mid/lvgl/src/draw/
    ../mid/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../mid/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../mid/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
  group mid/lvgl/src/font/
    ../mid/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group mid/lvgl/src/indev/
    ../mid/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group mid/lvgl/src/layouts/
    ../mid/lvgl/src/layouts/: lv_layout.c
    ../mid/lvgl/src/layouts/grid/: lv_grid.c
    ../mid/lvgl/src/layouts/flex/: lv_flex.c
  group mid/lvgl/src/libs/
    ../mid/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../mid/lvgl/src/libs/fsdrv/: lv_fs_littlefs.c
    ../mid/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group mid/lvgl/src/misc/
    ../mid/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../mid/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../mid/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../mid/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c
  group mid/lvgl/src/osal/
    ../mid/lvgl/src/osal/: lv_freertos.c lv_os.c
  group mid/lvgl/src/others/
    ../mid/lvgl/src/others/observer/: lv_observer.c
    ../mid/lvgl/src/others/sysmon/: lv_sysmon.c
  group mid/lvgl/src/stdlib/
    ../mid/lvgl/src/stdlib/: lv_mem.c
    ../mid/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group mid/lvgl/src/themes/
    ../mid/lvgl/src/themes/: lv_theme.c
    ../mid/lvgl/src/themes/default/: lv_theme_default.c
  group mid/lvgl/src/tick/
    ../mid/lvgl/src/tick/: lv_tick.c
  group mid/lvgl/src/widgets/
    ../mid/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../mid/lvgl/src/widgets/animimage/: lv_animimage.c
    ../mid/lvgl/src/widgets/arc/: lv_arc.c
    ../mid/lvgl/src/widgets/bar/: lv_bar.c
    ../mid/lvgl/src/widgets/button/: lv_button.c
    ../mid/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../mid/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../mid/lvgl/src/widgets/canvas/: lv_canvas.c
    ../mid/lvgl/src/widgets/chart/: lv_chart.c
    ../mid/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../mid/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../mid/lvgl/src/widgets/image/: lv_image.c
    ../mid/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../mid/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../mid/lvgl/src/widgets/label/: lv_label.c
    ../mid/lvgl/src/widgets/led/: lv_led.c
    ../mid/lvgl/src/widgets/line/: lv_line.c
    ../mid/lvgl/src/widgets/list/: lv_list.c
    ../mid/lvgl/src/widgets/lottie/: lv_lottie.c
    ../mid/lvgl/src/widgets/menu/: lv_menu.c
    ../mid/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../mid/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../mid/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../mid/lvgl/src/widgets/roller/: lv_roller.c
    ../mid/lvgl/src/widgets/scale/: lv_scale.c
    ../mid/lvgl/src/widgets/slider/: lv_slider.c
    ../mid/lvgl/src/widgets/span/: lv_span.c
    ../mid/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../mid/lvgl/src/widgets/spinner/: lv_spinner.c
    ../mid/lvgl/src/widgets/switch/: lv_switch.c
    ../mid/lvgl/src/widgets/table/: lv_table.c
    ../mid/lvgl/src/widgets/tabview/: lv_tabview.c
    ../mid/lvgl/src/widgets/textarea/: lv_textarea.c
    ../mid/lvgl/src/widgets/tileview/: lv_tileview.c
    ../mid/lvgl/src/widgets/win/: lv_win.c
  group user/
    ../user/: init.c irq.c main.c user.c
  group user/fs/
    ../user/fs/: ebd_fs.c etn_fs.c fs.c
  group user/gui/
    ../user/gui/: gui.c
  group user/gui/design/
    ../user/gui/design/: ui.c
    ../user/gui/design/screens/: ui_screen_screen1.c
  group user/gui/res/
    ../user/gui/res/arrary/: bg.c sbg.c
  group user/os/
    ../user/os/: os.c
